# Keil uVision project fyFLY.uvprojx, settings and files
target fyFLY (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: fyFLY +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,__TARGET_FPU_VFP,ARM_MATH_CM4,ARM_MATH_DSP
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS-DSP/PrivateInclude;../Drivers/CMSIS-DSP/Include;../Drivers/CMSIS/Include;../APPLICATION/inc;../BSP_DRIVER/inc;../BSP_DRIVER/Invn;../BSP_DRIVER/imu;../BSP_DRIVER
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\fyFLY\fyFLY.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group BSP_DRIVER
    ../BSP_DRIVER/src/: bsp_uartCallBack.c bsp_icm42670p.c bsp_lis3mdl.c bsp_sbus.c bsp_spl06.c lis3mdl_reg.c inv_time.c
    ../BSP_DRIVER/imu/: inv_imu_apex.c inv_imu_driver.c inv_imu_selftest.c inv_imu_transport.c
  group APPLICATION
    ../APPLICATION/inc/: common.h
    ../APPLICATION/src/: ringBuffer.c dataTransfer.c MahonyAHRS.c flyStateCtr.c flyRcCtr.c motoCtr.c app.c fyFilter.c
  group CMSIS/DSP
    ../Drivers/CMSIS-DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/BayesFunctions/: BayesFunctions.c
    ../Drivers/CMSIS-DSP/Source/CommonTables/: CommonTables.c
    ../Drivers/CMSIS-DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../Drivers/CMSIS-DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../Drivers/CMSIS-DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../Drivers/CMSIS-DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../Drivers/CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS-DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../Drivers/CMSIS-DSP/Source/SVMFunctions/: SVMFunctions.c
    ../Drivers/CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c
    ../Drivers/CMSIS-DSP/Source/WindowFunctions/: WindowFunctions.c
    ../Drivers/CMSIS-DSP/Source/SupportFunctions/: SupportFunctions.c
  group EKF
    ../APPLICATION/src/: kalman_filter.c QuaternionEKF.c user_lib.c
software components: CMSIS:CORE 6.0.0
